SUMMARY = "OP-TEE related test packages"

inherit packagegroup

RDEPENDS:packagegroup-ledge-optee = "\
    optee-test \
    "
