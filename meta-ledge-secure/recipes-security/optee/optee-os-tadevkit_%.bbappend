PV="3.18.0+git${SRCPV}"
SRCREV = "1ee647035939e073a2e8dddb727c0f019cc035f1"

DEPENDS:append = "dtc-native"
